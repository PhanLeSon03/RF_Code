# IAR project Backup of EWSTM8_project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\inc; ..\..\STM8S_StdPeriph_Driver\inc; ..\..\STM8_TouchSensing_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: EWSTM8_project.srec
  ILINK.IlinkOutputFile: EWSTM8_project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Include Files
    ../../STM8S_StdPeriph_Driver/inc/: Srb.h User.h
    ../inc/: stm8s_conf.h stm8s_it.h
  group Source Files
    ../src/: main.c Srb.c stm8s_it.c
    ../../STM8S_StdPeriph_Driver/src/: Main_Temp.c User.c
  group STM8S_StdPeriphLib/inc
    ../../STM8S_StdPeriph_Driver/inc/: stm8_onewire.h stm8s.h stm8s_adc1.h stm8s_awu.h stm8s_beep.h stm8s_clk.h stm8s_exti.h stm8s_flash.h stm8s_gpio.h stm8s_i2c.h stm8s_InRange32b.h stm8s_itc.h stm8s_iwdg.h stm8s_rst.h stm8s_spi.h stm8s_tim1.h stm8s_tim2.h stm8s_tim3.h stm8s_tim4.h stm8s_uart2.h stm8s_wwdg.h
  group STM8S_StdPeriphLib/src
    ../../STM8S_StdPeriph_Driver/src/: stm8_onewire.c stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart2.c stm8s_wwdg.c
