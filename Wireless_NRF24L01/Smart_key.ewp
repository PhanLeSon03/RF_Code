# IAR project Smart_key.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: Library\STM8L15x_StdPeriph_Driver\inc; Library\STM8L15x_StdPeriph_Driver\src; Library; D:\IAR Systems\Embedded Workbench 6.0\stm8\inc\c; D:\IAR Systems\Embedded Workbench 6.0\stm8\examples\ST-LINK\STM8L152C6-Board\Project\Demo\inc; D:\IAR Systems\Embedded Workbench 6.0\stm8\examples\ST-LINK\STM8L152C6-Board\Libraries\STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: Smart_key.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Application
    ./: main.c
  group C File
    Library/: NRF_24L01_P_Driver.c System_Init.c
    Library/STM8L15x_StdPeriph_Driver/src/: stm8l15x_clk.c stm8l15x_gpio.c stm8l15x_spi.c stm8l15x_syscfg.c
  group Driver
    Library/: global_variable.h NRF_24L01_P_Driver.h System_Init.h
    C:/Program Files/IAR Systems/Embedded Workbench 6.5/stm8/inc/: iostm8l152c6.h
    C:/Program Files/IAR Systems/Embedded Workbench 6.5/stm8/inc/c/: stdint.h string.h
    Library/STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h stm8l15x_clk.h stm8l15x_gpio.h stm8l15x_spi.h stm8l15x_syscfg.h
    C:/Program Files/IAR Systems/Embedded Workbench 6.5/stm8/examples/ST-LINK/STM8L152C6-Board/Project/Demo/inc/: stm8l15x_conf.h
