# IAR project test_stm8L.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L101F3P STM8L101F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L101
  ICCSTM8.CCIncludePath2: ..\Libraries\inc; ..\User
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: test_stm8L.srec
  ILINK.IlinkOutputFile: test_stm8L.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Libraries
    ../Libraries/src/: rf24l01.c stm8l10x_clk.c stm8l10x_exti.c stm8l10x_gpio.c stm8l10x_spi.c stm8l10x_tim2.c stm8l10x_tim3.c stm8l10x_tim4.c
    ../Libraries/inc/: stm8l10x_gpio.h
  group User
    ../User/: main.c stm8l10x_conf.h stm8l10x_it.c stm8l10x_it.h
