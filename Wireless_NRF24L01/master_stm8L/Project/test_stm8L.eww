<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\test_stm8L.ewp</path>
  </project>
  <batchBuild/>
</workspace>


