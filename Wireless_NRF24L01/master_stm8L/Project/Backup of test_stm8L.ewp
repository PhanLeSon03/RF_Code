# IAR project Backup of test_stm8L.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L101F3P STM8L101F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L101
  ICCSTM8.CCIncludePath2: D:\Working\Project\smart_lock\firmware\test\test_stm8L\Libraries\inc; D:\Working\Project\smart_lock\firmware\test\test_stm8L\User
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: test_stm8L.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Libraries
    ../Libraries/src/: stm8l10x_clk.c stm8l10x_gpio.c
    ../Libraries/inc/: stm8l10x_clk.h stm8l10x_gpio.h
  group User
    ../User/: main.c stm8l10x_conf.h stm8l10x_it.c stm8l10x_it.h
